Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , ,]
Time: 2021-10-08T09:06:44
Author: g.duna
Organization: VU.CITY
Written by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016
Made in: AutoCAD Architecture 2020 - English Build 8.2.47.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0110.07 : 20 Jan 2016 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 8 09:06:44 2021 * Host: LDNDSK019 * Database: C:\Users\GD0E9~1.DUN\AppData\Local\Temp\ACAIFCTMP/EDM18648\aec_ifc_db * Database version: 5507 * Database creation date: Fri Oct 8 09:06:05 2021 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Fri Oct 8 09:06:30 2021 * Header model: DataRepository.AecIfc_Header * Header model creation date: Fri Oct 8 09:06:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5649 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 000004
LongName: Sample_Tile_LOD2
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, Sample_Tile_LOD2
ElevationOfRefHeight: 0 in; ElevationOfTerrain: 0 in
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 ft2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 ft3; OneDayPotableWater: 0 ft3; OneDayEssentialWater: 0 ft3; OneDayCoolingTowerMakeupWater: 0 ft3; OneDayProcessOrProductionWater: 0 ft3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
